# Keil uVision project UCOS-1.uvprojx, settings and files
target UCOS-1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UCOS-1 +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\LED;..\HARDWARE\OLED;..\MODBUS;..\MODBUS\modbus;..\MODBUS\port;..\MODBUS\modbus\include;..\MODBUS\modbus\rtu;..\MALLOC;..\HARDWARE\W25QXX;..\HARDWARE\SDIO;..\HARDWARE\SRAM;..\HARDWARE\SPI;..\HARDWARE\KEY;..\HARDWARE\RTC;..\HARDWARE\CS5464;..\HARDWARE\IWDG;..\FWLIB\inc;..\HARDWARE\EXTI;..\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c stm32f4xx_it.c system_stm32f4xx.c convert.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/CS5464/: cs5464.c dc_cs5464.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_wwdg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_rcc.c stm32f4xx_iwdg.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_flash.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group MODBUS
    ../MODBUS/modbus/: mb.c
    ../MODBUS/modbus/rtu/: mbcrc.c mbrtu.c
    ../MODBUS/modbus/functions/: mbutils.c mbfuncother.c mbfuncinput.c mbfuncholding.c mbfuncdisc.c mbfuncdiag.c mbfunccoils.c
    ../MODBUS/port/: port.c portevent.c portserial.c porttimer.c
    ../MODBUS/: modbus.c
  group DOC
    ../: README.md
